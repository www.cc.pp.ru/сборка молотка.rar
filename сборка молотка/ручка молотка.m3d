# KOMPAS-3D part (ручка молотка.m3d)

Model tree:
1. Эскиз:1
2. Смещенная плоскость:1
     Расстояние = 220
3. Эскиз:2
4. Операция по сечениям:1
     Толщина стенки 1 = 1; Толщина стенки 2 = 1
